# Keil uVision project smartcar_c51.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: smartcar_c51
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 commandparser.c common.c delay.c lcd1602.c moto.c pwm.c rgbLed.c serial.c servo.c smartCar.c
